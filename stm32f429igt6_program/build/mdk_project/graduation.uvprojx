# Keil uVision project graduation.uvprojx, settings and files
target graduation (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: graduation +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,__FATFS
  c include: ..\..\start_up;..\..\cmsis\include;..\..\std_periph_diver\include;..\..\usr\include;..\..\usr\include\bsp;..\..\usr\include\app;..\..\usr\src\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\else\graduation.sct
  group start_up
    ../../start_up/: startup_stm32f429_439xx.s
  group cmsis
    ../../cmsis/src/: system_stm32f4xx.c
  group std_periph_driver
    ../../std_periph_diver/src/: misc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_i2c.c stm32f4xx_sdio.c
  group usr
    ../../usr/: main.c common.c stm32f4xx_it.c
  group bsp
    ../../usr/src/bsp/: bsp_led.c bsp_usart.c bsp_sdram.c bsp_systick.c bsp_ov2640.c bsp_sdio_sd.c
  group app
    ../../usr/src/app/: matrix.c template.c bmp.c cut.c image.c
  group fatfs
    ../../usr/src/fatfs/: diskio.c ff.c
    ../../usr/src/fatfs/option/: cc936.c
